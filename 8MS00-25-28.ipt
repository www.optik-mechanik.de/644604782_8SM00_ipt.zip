# Autodesk Inventor part: 8MS00-25-28
## iProperties
Created: 2007-10
Part Number: 8MS00-25-28
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
